# Keil uVision project Intelligent Vehicle.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Intelligent Vehicle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\DEVICE_LIB\inc;..\SYSTEM;..\SYSTEM\systick;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\led;..\SYSTEM\beep;..\SYSTEM\key;..\SYSTEM\wave;..\SYSTEM\wheel;..\SYSTEM\init;..\SYSTEM\basfn;..\SYSTEM\timer;..\SYSTEM\nvic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../SYSTEM/systick/: systick.c systick.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/led/: led.c led.h
    ../SYSTEM/beep/: beep.c beep.h
    ../SYSTEM/key/: key.c key.h
    ../SYSTEM/wave/: wave.c wave.h
    ../SYSTEM/wheel/: wheel.c wheel.h
    ../SYSTEM/init/: init.c init.h
    ../SYSTEM/basfn/: basfn.c basfn.h
    ../SYSTEM/pwm/: pwm.c pwm.h
    ../SYSTEM/timer/: timer.c timer.h
    ../SYSTEM/nvic/: nvic.c nvic.h
  group USER
    ./: main.c stm32f4xx_it.c
